pkg_postinst_ontarget_${PN}() {
  echo "Emphatically doing nothing for u-boot-fw-utils postinstall."
}

